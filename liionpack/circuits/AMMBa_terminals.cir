* C:\Users\tom\code\liionpack\AMMBa_terminals.asc
V1 N018 N034 V
V2 N019 N035 V
V3 N020 N036 V
V4 N021 N037 V
V5 N022 N038 V
V6 N023 N039 V
V7 N024 N040 V
V8 N025 N041 V
V9 N026 N042 V
V10 N027 N043 V
V11 N028 N044 V
V12 N029 N045 V
V13 N030 N046 V
V14 N031 N047 V
V15 N032 N048 V
V16 N033 N049 V
V17 N068 N084 V
V18 N069 N085 V
V19 N070 N086 V
V20 N071 N087 V
V21 N072 N088 V
V22 N073 N089 V
V23 N074 N090 V
V24 N075 N091 V
V25 N076 N092 V
V26 N077 N093 V
V27 N078 N094 V
V28 N079 N095 V
V29 N080 N096 V
V30 N081 N097 V
V31 N082 N098 V
V32 N083 N099 V
Ri1 N002 N018 R
Ri2 N003 N019 R
Ri3 N004 N020 R
Ri4 N005 N021 R
Ri5 N006 N022 R
Ri6 N007 N023 R
Ri7 N008 N024 R
Ri8 N009 N025 R
Ri9 N010 N026 R
Ri10 N011 N027 R
Ri11 N012 N028 R
Ri12 N013 N029 R
Ri13 N014 N030 R
Ri14 N015 N031 R
Ri15 N016 N032 R
Ri16 N017 N033 R
Ri17 N051 N068 R
Ri18 N052 N069 R
Ri19 N053 N070 R
Ri20 N054 N071 R
Ri21 N055 N072 R
Ri22 N056 N073 R
Ri23 N057 N074 R
Ri24 N058 N075 R
Ri25 N059 N076 R
Ri26 N060 N077 R
Ri27 N061 N078 R
Ri28 N062 N079 R
Ri29 N063 N080 R
Ri30 N064 N081 R
Ri31 N065 N082 R
Ri32 N066 N083 R
Rb1 N100 0 R
Rb2 N101 N100 R
Rb3 N102 N101 R
Rb4 N103 N102 R
Rb5 N104 N103 R
Rb6 N105 N104 R
Rb7 N106 N105 R
Rb8 N107 N106 R
Rb9 N109 N108 R
Rb10 N110 N109 R
Rb11 N111 N110 R
Rb12 N112 N111 R
Rb13 N113 N112 R
Rb14 N114 N113 R
Rb15 N115 N114 R
Rb16 N116 N115 R
Rb17 N002 N001 R
Rb18 N003 N002 R
Rb19 N004 N003 R
Rb20 N005 N004 R
Rb21 N006 N005 R
Rb22 N007 N006 R
Rb23 N008 N007 R
Rb24 N009 N008 R
Rb25 N011 N010 R
Rb26 N012 N011 R
Rb27 N013 N012 R
Rb28 N014 N013 R
Rb29 N015 N014 R
Rb30 N016 N015 R
Rb31 N017 N016 R
Rc1 N034 N051 R
Rc2 N035 N052 R
Rc3 N036 N053 R
Rc4 N037 N054 R
Rc5 N038 N055 R
Rc6 N039 N056 R
Rc7 N040 N057 R
Rc8 N041 N058 R
Rc9 N042 N059 R
Rc10 N043 N060 R
Rc11 N044 N061 R
Rc12 N045 N062 R
Rc13 N046 N063 R
Rc14 N047 N064 R
Rc15 N048 N065 R
Rc16 N049 N066 R
Rc17 N084 N100 R
Rc18 N085 N101 R
Rc19 N086 N102 R
Rc20 N087 N103 R
Rc21 N088 N104 R
Rc22 N089 N105 R
Rc23 N090 N106 R
Rc24 N091 N107 R
Rc25 N092 N108 R
Rc26 N093 N109 R
Rc27 N094 N110 R
Rc28 N095 N111 R
Rc29 N096 N112 R
Rc30 N097 N113 R
Rc31 N098 N114 R
Rc32 N099 N115 R
I1 N067 N050 I
Rl1 N010 N009 R
Rl2 N116 0 R
Rpos_terminal N001 N050 R
Rneg_terminal N067 0 R
.backanno
.end
